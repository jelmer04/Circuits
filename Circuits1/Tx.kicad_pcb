# Repository jelmer04/Circuits

## KiCad design Circuits1/Tx.kicad_pcb

Parts:
BT1: BATTERY
C1, C2: 18pF
C3, C4: 1uF
C5, C6, C7, C8, C9: 0.1uF
C10: 100nF
C11: 10uF
CON1: USB-MINI-B
D1: RX
D2: LED
D3: TX
Hole1, Hole2: CONN_1
JP1: Vcc Select
R1: 10K
R2, R3: 22
R4: 3K9
R5, R6, R7: 680
R10, R11: R
SW1: SW_PUSH
SW2: Power Select
U1: ATMEGA32U4; MODULE
U2: LD1117; MODULE
X1: QUARTZ

Connections:
3V3: C11.1, JP1.3, R10.1, R11.1, U2.2 (VOUT); also elsewhere on the board
+5V: C4.2, CON1.1 (VBUS), JP1.1, SW2.3 (C), U1.2 (UVcc), U1.7 (VBus)
/ICSP Header/MISO: U1.11 (MISO); also elsewhere on the board
/ICSP Header/MOSI: U1.10 (MOSI); also elsewhere on the board
/ICSP Header/SCK: U1.9 (SCK); also elsewhere on the board
/MPU/SCL: R11.2, U1.18 (SCL); also elsewhere on the board
/MPU/SDA: R10.2, U1.19 (SDA); also elsewhere on the board
/Radio/CE: U1.29 (PB5); also elsewhere on the board
/Radio/CSN: U1.30 (PB6); also elsewhere on the board
GND: BT1.2 (-), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.2, C11.2, CON1.5 (GND), CON1.6 (SHELL1), CON1.7 (SHELL2), CON1.8 (SHELL3), CON1.9 (SHELL4), D2.2 (K), R4.1, R5.2, R7.2, SW1.1, U1.5 (UGnd), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), U2.1 (GND); also elsewhere on the board
unnamed: R6.1, U1.32 (PC7)
unnamed: D2.1 (A), R6.2
unnamed: C2.2, U1.17 (XTAL2), X1.1
unnamed: D3.1 (A), U1.22 (PD5)
unnamed: D3.2 (K), R7.1
unnamed: D1.2 (K), R5.1
unnamed: D1.1 (A), U1.8 (PB0)
unnamed: C10.1, SW2.2 (B), U2.3 (VIN)
unnamed: R4.2, U1.33 (HWB)
unnamed: BT1.1 (+), SW2.1 (A)
unnamed: C1.2, U1.16 (XTAL1), X1.2
unnamed: C8.2, U1.42 (AREF)
unnamed: C3.2, U1.6 (UCap)
unnamed: R2.2, U1.4 (D+)
unnamed: R3.2, U1.3 (D-)
unnamed: CON1.3 (D+), R2.1
unnamed: CON1.2 (D-), R3.1
RESET: R1.2, SW1.2, U1.13 (RESET); also elsewhere on the board
VCC: C5.2, C6.2, C7.2, C9.2, JP1.2, R1.1, U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC); also elsewhere on the board

Parts:
A1: Antenna
C12: 33nF
C13: 10nF
C14: 1nF
C15: 1.5pF
C16, C17: 22pF
C18: 4.7pF
C19: 1pF
C20: 2.2nF
L1: 8.2nH
L2: 3.9nH
L3: 2.7nH
R8: 22K
R9: 1M
U3: NRF24L01+; MODULE
X2: QUARTZ

Connections:
3V3: C13.1, C14.1, U3.7, U3.15, U3.18; also elsewhere on the board
/ICSP Header/MISO: U3.5; also elsewhere on the board
/ICSP Header/MOSI: U3.4; also elsewhere on the board
/ICSP Header/SCK: U3.3; also elsewhere on the board
/Radio/CE: U3.1; also elsewhere on the board
/Radio/CSN: U3.2; also elsewhere on the board
ANTENNA: A1.1, C15.2, C19.1
GND: A1.2 (PM), C12.1, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, R8.1, U3.8, U3.14, U3.17, U3.20; also elsewhere on the board
unnamed: R8.2, U3.16
unnamed: C16.1, R9.1, U3.10, X2.2
unnamed: C15.1, L2.2
unnamed: C12.2, U3.19
unnamed: L1.2, L3.1, U3.12
unnamed: C17.1, R9.2, U3.9, X2.1
unnamed: L1.1, L2.1, U3.13
unnamed: C18.1, C20.1, L3.2, U3.11

Parts:
P1: CONN_3X2

Connections:
/ICSP Header/MISO: P1.1; also elsewhere on the board
/ICSP Header/MOSI: P1.4; also elsewhere on the board
/ICSP Header/SCK: P1.3; also elsewhere on the board
GND: P1.6; also elsewhere on the board
RESET: P1.5; also elsewhere on the board
VCC: P1.2; also elsewhere on the board

Parts:
C21, C23: 0.1uF
C22: 10nF
C24: 2.2nF
U4: MPU-6050; MODULE

Connections:
3V3: C21.2, C22.2, U4.8 (VLOGIC), U4.13 (VDD); also elsewhere on the board
/MPU/SCL: U4.23 (SCL); also elsewhere on the board
/MPU/SDA: U4.24 (SDA); also elsewhere on the board
GND: C21.1, C22.1, C23.2, C24.2, U4.9 (AD0), U4.18 (GND); also elsewhere on the board
unnamed: C24.1, U4.20 (CPOUT)
unnamed: C23.1, U4.10 (REGOUT)

Board: 2 copper layers, 38.0 x 53.3 mm, 56 parts (3 on the bottom side), 40 nets.

## Commit log

2013-12-16 RX and Radio
2013-12-22 PCB Layout with 0806
2013-12-23 Antenna and Ground Planes
2013-12-23 Vias Stitched
2014-01-21 Tx Circuitry Week 1
2014-01-22 Tx Ground Planes
2014-01-24 BOMs
2014-01-26 Antenna Position
2014-02-28 PDFs
2014-03-24 Neatened Schematics and Final PCB
2014-05-16 Neatened up for report
